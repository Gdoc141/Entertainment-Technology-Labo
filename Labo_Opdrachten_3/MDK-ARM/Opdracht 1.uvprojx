# Keil uVision project Opdracht 1.uvprojx, settings and files
target Opdracht 1 (6240000::V6.24::ARMCLANG)
  device: STM32H533RETx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20043FFF) IROM(0x08000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Opdracht 1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_NUCLEO_64,USE_HAL_DRIVER,STM32H533xx
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/BSP/STM32H5xx_Nucleo;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/tinyusb/src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x44000
  group Application/MDK-ARM
    ./: startup_stm32h533xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/BSP/STM32H5xx_Nucleo
    ../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_icache.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_ll_usb.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group TinyUSB
    ../Middlewares/Third_Party/tinyusb/src/: tusb.c
    ../Middlewares/Third_Party/tinyusb/src/common/: tusb_fifo.c
    ../Middlewares/Third_Party/tinyusb/src/device/: usbd.c usbd_control.c
    ../Middlewares/Third_Party/tinyusb/src/class/midi/: midi_device.c
    ../Middlewares/Third_Party/tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c fsdev_common.c
    ../Core/Src/: usb_descriptors.c
    ../Core/Inc/: tusb_config.h
software components: CMSIS:CORE 4.3.0
